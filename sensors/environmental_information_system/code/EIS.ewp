# IAR project EIS.ewp, settings and files
configuration HW-V2-Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 1024
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: HARDWARE_VERSION=2
  ICC430.newCCIncludePaths: ; HAL\; USB\; USB_config\; USB_Common\; USB_CDC_API\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6638.xcl
  XLINK.XlinkStackSize: 1
configuration HW-V1-Debug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F6658 MSP430F6658
  ICC430.CCDefines: HARDWARE_VERSION=1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6658.xcl
  group Application
    ./: 2D_Flow.c 2D_Flow.h BME280.c BME280.h BQ27200.c BQ27200.h BQ27421-G1.c BQ27421-G1.h EE893.c EE893.h FlowX_Values.h FlowY_Values.h font.h Globals.h hardware.h Hardware_new.h Hardware_old.h I2C_USCI_Modul.c I2C_USCI_Modul.h IPv6.c IPv6.h main.c main.h OLED.c OLED.h OLED_Texte.h Radio_Task.c Radio_Task.h RF430.c RF430.h Si1132.c Si1132.h SPI_UCSI_Modul.c SPI_UCSI_Modul.h Task_Manager.c Task_Manager.h UART_UCA1_Modul.c UART_UCA2_Modul.c UART_USCI.c UART_USCI.h UnusedInterrupts.c USB_PC_Com.c USB_PC_Com.h
  group HAL
    HAL/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h low_level_init.c MSP430Utils.h pre_init.c
  group LWM2M
    ./: LWM2M.c LWM2M.h LWM2M_BME280_Resources.c LWM2M_BME280_Resources.h LWM2M_Flow_Resources.c LWM2M_Flow_Resources.h LWM2M_MessData_Resources.c LWM2M_MessData_Resources.h LWM2M_Si1132_Resources.c LWM2M_Si1132_Resources.h LWM2M_Utils.c LWM2M_Utils.h
  group USB
    USB/: usbConstructs.c usbConstructs.h usbEventHandling.c
  group USB/CDC
    USB_CDC_API/: types.h UsbCdc.c UsbCdc.h
  group USB/Common
    USB_Common/: defMSP430USB.h device.h dma.c stdint.h types.h usb.c usb.h UsbIsr.h
  group USB/Config
    USB_config/: descriptors.c descriptors.h UsbIsr.c
