# IAR project Backup (4) of emeter-toolkit-6779.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xsmfn.h
  General.OGChipSelectMenu: MSP430F67791 MSP430F67791
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../emeter-toolkit
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL=1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F47197.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: accum48.s43 bin2bcd16.s43 bin2bcd32.s43 dc_filter16.s43 dc_filter24.s43 dds.c debounce.c div48.c div_sh48.c flash_clr.c flash_memcpy.c flash_replace16.c flash_replace32.c flash_secure.c flash_write_int16.c flash_write_int32.c flash_write_int8.c hex2ASCII.c host_char.c host_dec16.c host_dec32.c host_decu16.c host_decu32.c host_hex16.c host_hex32.c host_str.c iiceeprom.c imul16.s43 isqrt16.s43 isqrt32.s43 isqrt32i.c isqrt64.s43 isqrt64i.c LCD-internal.c LCD-module.c LCD-sim.c LCDdec16.c LCDdec32.c LCDdecu16.c LCDdecu32.c mac48.s43 mac48_16_24.s43 mac64_16_24.s43 mul48.c mul48_32_16.s43 mul48u_32_16.s43 q1_15_mul.s43 q1_15_mulr.s43 rand16.c rtc.c rtc_data.c setdco.c shift48.s43 sqac48_16.s43 sqac64_24.s43
