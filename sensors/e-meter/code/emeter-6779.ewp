# IAR project emeter-6779.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430F6779 MSP430F6779
  General.GStackSize2: 300
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CUSTOM_EMETER_H="emeter-3ph-neutral-6779.h"; __MSP430F67791__; UCA3_USED
  ICC430.newCCIncludePaths: ; emeter-toolkit/
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6779.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCDefines: CUSTOM_EMETER_H="emeter-3ph-neutral-6779.h"; __MSP430F67791__; UCA3_USED; FULL_INIT
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  group EMETER
    ./: emeter-3ph-neutral-6779.h emeter-background.c emeter-communication.c emeter-communication.h emeter-dlt645.c emeter-fir-table.c emeter-foreground.c emeter-main.c emeter-multirate.h emeter-rtc.c emeter-rtc.h emeter-setup.c emeter-structs.h
    emeter-toolkit/Debug/Exe/: emeter-toolkit-6779.r43
  group HW
    emeter-toolkit/: HAL_Dogs102x6.c
    ./: hal_pmm.c hal_pmm.h hal_UCS.c hal_UCS.h Hardware.h
  group I2C
    ./: I2C_USCI_Modul.c I2C_USCI_Modul.h
  group LWM2M
    ./: LWM2M.c LWM2M.h LWM2M_App.c LWM2M_App.h LWM2M_Transport_CRC.c LWM2M_Transport_CRC.h LWM2M_TransportLayer.c LWM2M_TransportLayer.h RadioEsimaLWM2M.c RadioEsimaLWM2M.h
  group NFC
    ./: RF430.c RF430.h
  group TIMER
    ./: Timer_Modul.c Timer_Modul.h
  group UART
    ./: UART_UCA3_Modul.c UART_USCI.c UART_USCI.h
