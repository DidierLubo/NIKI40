# IAR project Backup of emeter-6779.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F6779 MSP430F6779
  General.GStackSize2: 300
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CUSTOM_EMETER_H="emeter-3ph-neutral-6779.h"; __MSP430F67791__
  ICC430.newCCIncludePaths: ; emeter-toolkit/
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F6779.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: emeter-background.c emeter-communication.c emeter-dlt645.c emeter-fir-table.c emeter-foreground.c emeter-main.c emeter-phase-corrections.c emeter-rtc.c emeter-setup.c hal_pmm.c hal_UCS.c
    emeter-toolkit/Debug/Exe/: emeter-toolkit-6779.r43
    emeter-toolkit/: HAL_Dogs102x6.c
